# Keil uVision project Platform.uvprojx, settings and files
target STM32L552E-EV (6140000::V6.14::ARMCLANG)
  device: STM32L552ZETxQ STMicroelectronics
  pack: Keil.STM32L5xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x30000000,0x00040000) IROM(0x08000000,0x00080000) IROM2(0x0C000000,0x00080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: Platform
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\Board_IO
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0xc000000 size 0x80000
  memory RVCT6: RAM 0x2003f800 size 0x800
  memory RVCT9: RAM 0x20000000 size 0x3f800
  memory RVCT10: RAM 0x30000000 size 0x40000
  scatter file: .\RTE\Device\STM32L552ZETxQ\stm32l552xe_flash.sct
  group App
    ./: Platform.c
  group Board IO
    ./Board_IO/: retarget_stdio.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32L552ZETxQ/STCubeGenerated/Src/: main.c stm32l5xx_it.c
    ./RTE/Device/STM32L552ZETxQ/STCubeGenerated/Inc/: stm32l5xx_it.h
  group STM32CubeMX
    ./RTE/Device/STM32L552ZETxQ/STCubeGenerated/: STCubeGenerated.ioc
  group Documentation
    ./: README.md
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.5.2, Compiler:Event Recorder 1.4.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Board Support:Components:HX8347I 2.0.0, Board Support:Components:MFXSTM32L152 3.0.2, Board Support:Drivers:BUS 1.0.1, Board Support:Drivers:Basic I/O 1.0.1, Board Support:Drivers:IO 1.0.1, Board Support:Drivers:LCD 1.0.1, CMSIS Driver:SPI 1.0.0, CMSIS Driver:USART 1.0.0, CMSIS Driver:VIO:Board 1.0.0, Device:STM32Cube HAL:ADC 1.0.2, Device:STM32Cube HAL:Common 1.0.0, Device:STM32Cube HAL:Cortex 1.0.2, Device:STM32Cube HAL:DMA 1.0.2, Device:STM32Cube HAL:EXTI 1.0.2, Device:STM32Cube HAL:Flash 1.0.2, Device:STM32Cube HAL:GPIO 1.0.2, Device:STM32Cube HAL:I2C 1.0.2, Device:STM32Cube HAL:ICACHE 1.0.2, Device:STM32Cube HAL:IRDA 1.0.2, Device:STM32Cube HAL:PWR 1.0.2, Device:STM32Cube HAL:RCC 1.0.2, Device:STM32Cube HAL:SPI 1.0.2, Device:STM32Cube HAL:SRAM 1.0.2, Device:STM32Cube HAL:Smartcard 1.0.2, Device:STM32Cube HAL:UART 1.0.2, Device:STM32Cube HAL:USART 1.0.2, Device:Startup 1.0.2
