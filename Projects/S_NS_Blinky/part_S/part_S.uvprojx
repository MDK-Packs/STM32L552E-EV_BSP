# Keil uVision project part_S.uvprojx, settings and files
target STM32L552E-EV (6140000::V6.14::ARMCLANG)
  device: STM32L552ZETxQ STMicroelectronics
  pack: Keil.STM32L5xx_DFP.1.2.1-dev3
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x30000000,0x00030000) IROM(0x08000000,0x00080000) IROM2(0x0C000000,0x00080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: part_S
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: VIO_LCD_DISABLE
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0xc000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x30000000 size 0x18000
  scatter file: .\part_S.sct
  group Source Group 1
    ./: main_s.c
  group Documentation
    ../: Abstract.txt
software components: CMSIS:CORE 5.4.0, Board Support:Components:HX8347I 2.0.0, Board Support:Components:MFXSTM32L152 3.0.2, Board Support:Drivers:BUS 1.0.1, Board Support:Drivers:Basic I/O 1.0.1, Board Support:Drivers:IDD 1.0.1, Board Support:Drivers:IO 1.0.1, Board Support:Drivers:LCD 1.0.1, Board Support:LED 1.0.1, CMSIS Driver:VIO:Board 1.0.0, Device:STM32Cube HAL:ADC 1.0.2, Device:STM32Cube HAL:Common 1.0.0, Device:STM32Cube HAL:Cortex 1.0.2, Device:STM32Cube HAL:DMA 1.0.2, Device:STM32Cube HAL:EXTI 1.0.2, Device:STM32Cube HAL:Flash 1.0.2, Device:STM32Cube HAL:GPIO 1.0.2, Device:STM32Cube HAL:GTZC 1.0.2, Device:STM32Cube HAL:I2C 1.0.2, Device:STM32Cube HAL:PWR 1.0.2, Device:STM32Cube HAL:RCC 1.0.2, Device:STM32Cube HAL:SRAM 1.0.2, Device:STM32Cube HAL:UART 1.0.2, Device:Startup 1.0.2
